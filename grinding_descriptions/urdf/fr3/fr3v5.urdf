Commit message: Update

File: grinding_descriptions/urdf/fr3/fr3v5.urdf (robot description, URDF)
Before this commit: robot fr3v5, 13 links, 12 joints
Links:
- link tool_Link: geometry collision box size=0 0 0; visual box size=0 0 0
